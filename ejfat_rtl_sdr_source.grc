options:
  parameters:
    author: yak
    generate_options: qt_gui
    id: efjat_rtl_sdr_src
    output_language: python
    title: RTL SDR source for EJFAT demos
  states: {}

blocks:
- name: fm_channel
  id: variable_qtgui_range
  parameters:
    start: 99.1E6
    step: '100000'
    stop: 108.1E6
    value: 106.1E6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '5'
    stop: '70'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2048E3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '16'
    quad_rate: '512000'
  states: {state: disabled}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '16'
    deemph_tau: '75e-6'
    quad_rate: '512000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '32000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '50000'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_KAISER
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    clock_source0: internal
    freq0: fm_channel
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: fm_channel
    fftsize: '1024'
    gui_hint: 1,0,1,2
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '200000'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '200000'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,1,1,1
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fm_channel
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0_0, '0']
- [analog_wfm_rcv_pll_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_pll_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0, '1']
- [analog_wfm_rcv_pll_0, '1', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
