options:
  parameters:
    author: yak
    generate_options: qt_gui
    id: EFJAT_header_insert
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ejfat_packet.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ejfat_packet_2.bin
    type: float
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: '100'
    type: float
    vector: '[0xDE, 0xAD , 0xBE , 0xEF]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4'
    type: float
  states: {}
- name: ejfat_ejfat_sink_0
  id: ejfat_ejfat_sink
  parameters:
    eventID: '0'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: float
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2000'
    src_zeros: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vector_insert_x_0, '0']
- [analog_sig_source_x_0, '0', ejfat_ejfat_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_insert_x_0, '0', network_udp_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0, '1']
- [ejfat_ejfat_sink_0, '0', blocks_vector_to_stream_0, '0']
- [network_udp_source_0, '0', blocks_file_sink_0_0, '0']
- [network_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
