options:
  parameters:
    author: yak
    generate_options: no_gui
    id: test_ejfat_udp_source
    output_language: python
    title: EJFAT UDP Source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {}
- name: test_core_0
  id: test_core
  parameters:
    samp_rate: '10000'
  states: {}

connections:
- [test_core_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
