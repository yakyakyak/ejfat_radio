options:
  parameters:
    author: yak
    generate_options: no_gui
    id: test_no_gui
    output_language: python
    title: test no gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: test_core_0
  id: test_core
  parameters:
    samp_rate: samp_rate
  states: {}

connections:
- [test_core_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
